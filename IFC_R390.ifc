Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-12-11T17:33:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 11 17:33:25 2020 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{D2A0CCA9-74E8-4945-B44A-40C7BD681877}\ifc * Database version: 5507 * Database creation date: Fri Dec 11 17:33:22 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 11 17:33:22 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 11 17:33:22 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Battery Operated Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R390:Battery Operated Brushed Stainless Steel:311474
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Chrome, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R390:Battery Operated Chrome:311517
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Chrome; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R390:Mains Operated Brushed Stainless Steel:311587
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Chrome, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R390:Mains Operated Chrome:311800
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Polished Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
